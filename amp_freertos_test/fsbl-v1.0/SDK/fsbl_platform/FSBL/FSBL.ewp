# IAR project FSBL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCIncludePath2: FM_QL_hw_platform; FM_QL_fsbl; FM_QL_bsp\include; FM_QL_bsp\bootloader; FM_QL_bsp\libsrc; FSBL_bsp\lib; FM_QL_bsp\libsrc\common_v1_0; FM_QL_bsp\libsrc\devcps_v1_0; FM_QL_bsp\libsrc\dmaps_v1_0; FM_QL_bsp\libsrc\gicps_v1_0; FM_QL_bsp\libsrc\FatFs; FM_QL_bsp\libsrc\nfcps_v1_0; FM_QL_bsp\libsrc\qspips_v1_0; FM_QL_bsp\libsrc\sdmmcps_v1_0; FM_QL_bsp\libsrc\secure_v1_0; FM_QL_bsp\libsrc\uartps_v1_0; FM_QL_bsp\libsrc\ttcps_v1_0; FM_QL_bsp\libsrc\wdtps_v1_0; FM_QL_bsp\libsrc\slcrps_v1_0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fsbl.bin
  ILINK.IlinkOutputFile: FSBL.out
  ILINK.IlinkIcfFile: a7_sram.icf
  ILINK.IlinkAdditionalLibs: FM_QL_bsp\lib\librsa.a
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: FM_QL_hw_platform; FM_QL_fsbl; FM_QL_bsp\include; FM_QL_bsp\bootloader; FM_QL_bsp\libsrc; FSBL_bsp\lib; FM_QL_bsp\libsrc\common_v1_0; FM_QL_bsp\libsrc\devcps_v1_0; FM_QL_bsp\libsrc\dmaps_v1_0; FM_QL_bsp\libsrc\gicps_v1_0; FM_QL_bsp\libsrc\FatFs; FM_QL_bsp\libsrc\nfcps_v1_0; FM_QL_bsp\libsrc\qspips_v1_0; FM_QL_bsp\libsrc\sdmmcps_v1_0; FM_QL_bsp\libsrc\secure_v1_0; FM_QL_bsp\libsrc\uartps_v1_0; FM_QL_bsp\libsrc\ttcps_v1_0; FM_QL_bsp\libsrc\wdtps_v1_0
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: FSBL.bin
  group FM_QL_bsp/ps_a7/bootloader
    FM_QL_bsp/bootloader/: cache.c cache.h exception_handler.c exception_handler.h init.s mmu_table.s
  group FM_QL_bsp/ps_a7/include
    FM_QL_bsp/include/: fmsh_ps_parameters.h
  group FM_QL_bsp/ps_a7/lib
    FM_QL_bsp/lib/: librsa.a MPSoc_RSA2048.lib
  group FM_QL_bsp/ps_a7/libsrc/common_v1_0
    FM_QL_bsp/libsrc/common_v1_0/: fmsh_common.c fmsh_common.h fmsh_common_bitops.h fmsh_common_dbc.h fmsh_common_delay.h fmsh_common_dev.h fmsh_common_io.h fmsh_common_list.h fmsh_common_status.h fmsh_common_types.h
  group FM_QL_bsp/ps_a7/libsrc/devcps_v1_0
    FM_QL_bsp/libsrc/devcps_v1_0/: fdevcps.c fdevcps_common.h fdevcps_private.h fdevcps_public.h
  group FM_QL_bsp/ps_a7/libsrc/dmaps_v1_0
    FM_QL_bsp/libsrc/dmaps_v1_0/: fmsh_dmac.c fmsh_dmac.h fmsh_dmac_g.c fmsh_dmac_hw.h fmsh_dmac_lib.h fmsh_dmac_private.h fmsh_dmac_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/FatFs
    FM_QL_bsp/libsrc/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group FM_QL_bsp/ps_a7/libsrc/gic
    FM_QL_bsp/libsrc/gicps_v1_0/: fmsh_gic.c fmsh_gic.h fmsh_gic_hw.h fmsh_gic_intr.c fmsh_gic_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/nfcps_v1_0
    FM_QL_bsp/libsrc/nfcps_v1_0/: fmsh_nfcps.c fmsh_nfcps.h fmsh_nfcps_bbm.c fmsh_nfcps_bbm.h fmsh_nfcps_flash.c fmsh_nfcps_flash.h fmsh_nfcps_g.c fmsh_nfcps_hw.c fmsh_nfcps_hw.h fmsh_nfcps_lib.h fmsh_nfcps_model.c fmsh_nfcps_model.h fmsh_nfcps_sinit.c fmsh_nfcps_skipblock.c fmsh_nfcps_skipblock.h fmsh_nfcps_sw.c fmsh_nfcps_sw.h
  group FM_QL_bsp/ps_a7/libsrc/qspips_v1_0
    FM_QL_bsp/libsrc/qspips_v1_0/: fmsh_qspips.c fmsh_qspips.h fmsh_qspips_flash.c fmsh_qspips_flash.h fmsh_qspips_g.c fmsh_qspips_hw.c fmsh_qspips_hw.h fmsh_qspips_lib.h fmsh_qspips_sinit.c fmsh_qspips_sw.c fmsh_qspips_sw.h
  group FM_QL_bsp/ps_a7/libsrc/sdmmcps_v1_0
    FM_QL_bsp/libsrc/sdmmcps_v1_0/: fmsh_sdmmc.c fmsh_sdmmc.h fmsh_sdmmc_g.c fmsh_sdmmc_hw.h fmsh_sdmmc_lib.h fmsh_sdmmc_private.h fmsh_sdmmc_protocol.c fmsh_sdmmc_protocol.h fmsh_sdmmc_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/secure_v1_0
    FM_QL_bsp/libsrc/secure_v1_0/: fmsh_aes_sm4.c fmsh_aes_sm4.h fmsh_authentication.c fmsh_authentication.h fmsh_csudma.c fmsh_csudma.h fmsh_efuse.c fmsh_efuse.h fmsh_sha.h fmsh_sha256.c
  group FM_QL_bsp/ps_a7/libsrc/slcrps_v1_0
    FM_QL_bsp/libsrc/slcrps_v1_0/: fmsh_slcr.c fmsh_slcr.h
  group FM_QL_bsp/ps_a7/libsrc/uartps_v1_0
    FM_QL_bsp/libsrc/uartps_v1_0/: fmsh_uart.c fmsh_uart_common.h fmsh_uart_g.c fmsh_uart_lib.h fmsh_uart_private.h fmsh_uart_public.h fmsh_uart_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/wdtps_v1_0
    FM_QL_bsp/libsrc/wdtps_v1_0/: fmsh_wdt.c fmsh_wdt_common.h fmsh_wdt_lib.h fmsh_wdt_private.h fmsh_wdt_public.h
  group FM_QL_fsbl
    FM_QL_fsbl/: boot_main.h boothandoff.c fmsh_dma.c fmsh_dma.h fmsh_dmac_config.c fmsh_dmac_config.h fmsh_error.h fmsh_exit.s fmsh_fnand.c fmsh_fnand.h fmsh_gic_selftest.c fmsh_header.c fmsh_header.h fmsh_initialization.c fmsh_nor.c fmsh_nor.h fmsh_partition_load.c fmsh_qspi.c fmsh_qspi.h fmsh_sac.c fmsh_sac.h fmsh_sd.c fmsh_sd.h fmsh_uart_logout.c fmsh_uart_logout.h fmsh_watchdog.c fmsh_watchdog.h main.c
  group FM_QL_hw_platform
    FM_QL_hw_platform/: ps_init.c ps_init.h
