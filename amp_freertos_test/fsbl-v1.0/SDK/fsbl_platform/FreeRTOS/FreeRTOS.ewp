# IAR project FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCIncludePath2: Demo\Common\include; \Demo\RTOSDemo; FM_QL_hw_platform; Source\include; Source\portable\IAR\ARM_CA7; ..\FM_QL_bsp\include; ..\FM_QL_bsp\bootloader; ..\FM_QL_bsp\libsrc\common_v1_0; ..\FM_QL_bsp\libsrc\gicps_v1_0; ..\FM_QL_bsp\libsrc\gpiops_v1_0; ..\FM_QL_bsp\libsrc\gtcps_v1_0; ..\FM_QL_bsp\libsrc\ttcps_v1_0; ..\FM_QL_bsp\libsrc\uartps_v1_0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Demo\RTOSDemo; FM_QL_hw_platform
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: a7_sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FM_QL_bsp/bootloader
    ../FM_QL_bsp/bootloader/: cache.c cache.h cstartup.s exception_handler.c exception_handler.h mmu_table.s
  group FM_QL_bsp/include
    ../FM_QL_bsp/include/: fmsh_parameters.h fmsh_ps_parameters.h
  group FM_QL_bsp/libsrc/common_v1_0
    ../FM_QL_bsp/libsrc/common_v1_0/: fmsh_common.c fmsh_common.h fmsh_common_bitops.h fmsh_common_dbc.h fmsh_common_delay.h fmsh_common_dev.h fmsh_common_io.h fmsh_common_list.h fmsh_common_status.h fmsh_common_types.h
  group FM_QL_bsp/libsrc/ddr3ps_v1_0
    ../FM_QL_bsp/libsrc/ddr3ps_v1_0/: fmsh_testmem.c fmsh_testmem.h
  group FM_QL_bsp/libsrc/dmaps_v1_0
    ../FM_QL_bsp/libsrc/dmaps_v1_0/: fmsh_dmac.c fmsh_dmac.h fmsh_dmac_g.c fmsh_dmac_hw.h fmsh_dmac_lib.h fmsh_dmac_private.h fmsh_dmac_sinit.c
  group FM_QL_bsp/libsrc/gicps_v1_0
    ../FM_QL_bsp/libsrc/gicps_v1_0/: fmsh_gic.c fmsh_gic.h fmsh_gic_hw.h fmsh_gic_intr.c fmsh_gic_sinit.c
  group FM_QL_bsp/libsrc/gpiops_v1_0
    ../FM_QL_bsp/libsrc/gpiops_v1_0/: fmsh_gpio.c fmsh_gpio_common.h fmsh_gpio_g.c fmsh_gpio_lib.h fmsh_gpio_private.h fmsh_gpio_public.h fmsh_gpio_sinit.c
  group FM_QL_bsp/libsrc/gtcps_v1_0
    ../FM_QL_bsp/libsrc/gtcps_v1_0/: fmsh_gtc.c fmsh_gtc_common.h fmsh_gtc_g.c fmsh_gtc_lib.h fmsh_gtc_private.h fmsh_gtc_public.h fmsh_gtc_sinit.c
  group FM_QL_bsp/libsrc/ttcps_v1_0
    ../FM_QL_bsp/libsrc/ttcps_v1_0/: fmsh_ttc.c fmsh_ttc_common.h fmsh_ttc_g.c fmsh_ttc_lib.h fmsh_ttc_private.h fmsh_ttc_public.h fmsh_ttc_sinit.c
  group FM_QL_bsp/libsrc/uartps_v1_0
    ../FM_QL_bsp/libsrc/uartps_v1_0/: fmsh_uart.c fmsh_uart_common.h fmsh_uart_g.c fmsh_uart_lib.h fmsh_uart_private.h fmsh_uart_public.h fmsh_uart_sinit.c
  group FM_QL_hw_platform
    FM_QL_hw_platform/: ps_init.c
  group FreeRTOS
    Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Source/portable/MemMang/: heap_4.c
    Source/portable/IAR/ARM_CA7/: port.c portASM.s
  group FreeRTOS_Demo
    Demo/RTOSDemo/: fmsh_print.c fmsh_print.h FreeRTOS_asm_vectors.S FreeRTOS_tick_config.c led_flash.c main.c ParTest.c platform.c platform.h platform_config.h
